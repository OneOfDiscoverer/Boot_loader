# Keil uVision project Boot_loader.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Boot_loader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc;..\inc;D:\Firmware;..\Lib_gen\inc
  asm include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./src/: main.c Flash_msp.c Main_thread.c Linear_func.c gpio_init.c usart.c
    ./inc/: MEM_map.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
